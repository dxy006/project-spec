SRC_URI += "file://user_2020-10-18-22-53-00.cfg \
            file://user_2020-12-26-15-22-00.cfg \
            file://user_2020-12-26-16-47-00.cfg \
            file://user_2020-12-28-00-32-00.cfg \
            file://user_2020-12-28-10-44-00.cfg \
            file://user_2021-01-13-17-07-00.cfg \
            file://user_2021-01-18-21-40-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

