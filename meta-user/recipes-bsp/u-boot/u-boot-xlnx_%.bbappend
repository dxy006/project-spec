FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2021-01-13-22-59-00.cfg \
            file://user_2021-01-13-23-07-00.cfg \
            file://user_2021-01-15-18-58-00.cfg \
            file://user_2021-01-15-21-32-00.cfg \
            "
